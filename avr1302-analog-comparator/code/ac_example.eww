<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\AC_example_polled.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\AC_example_window_and_interrupt.ewp</path>
  </project>
  <batchBuild/>
</workspace>


